# Repository numato/samplecode (continued)

## KiCad design FPGA/Saturn/board/saturn.kicad_pcb (continued)

Parts:
C16, C83: 15pF
C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C63, C64, C84: 0.01uF
D1: LED
GS5, GS6, GS7: GS2
P1: CONN_7X2
R14, R17, R19: 4.7K
R15, R16: 10K
R18: 1K
R31, R32, R33, R34: 0R
U4, U10: FXO-HC536R
U5: SPARTAN6LXXXX-CSG324

Connections:
/FTDI2232H/PROGB: R19.1, U5.V2; also elsewhere on the board
/FTDI2232H/TCK: P1.6, R31.1; also elsewhere on the board
/FTDI2232H/TDI: P1.10, R32.1; also elsewhere on the board
/FTDI2232H/TDO: P1.8, R34.1; also elsewhere on the board
/FTDI2232H/TMS: P1.4, R33.1; also elsewhere on the board
/FTDI2232H/U1-CS: U5.V3; also elsewhere on the board
/FTDI2232H/U1-D0: U5.L17; also elsewhere on the board
/FTDI2232H/U1-D1: U5.L18; also elsewhere on the board
/FTDI2232H/U1-D2: U5.M16; also elsewhere on the board
/FTDI2232H/U1-D3: U5.M18; also elsewhere on the board
/FTDI2232H/U1-D4: U5.N17; also elsewhere on the board
/FTDI2232H/U1-D5: U5.N18; also elsewhere on the board
/FTDI2232H/U1-D6: U5.P17; also elsewhere on the board
/FTDI2232H/U1-D7: U5.P18; also elsewhere on the board
/FTDI2232H/U1-RD#: U5.J18; also elsewhere on the board
/FTDI2232H/U1-RXF#: U5.K18; also elsewhere on the board
/FTDI2232H/U1-SCK: U5.R15; also elsewhere on the board
/FTDI2232H/U1-SDI: U5.R13; also elsewhere on the board
/FTDI2232H/U1-SDO: U5.T13; also elsewhere on the board
/FTDI2232H/U1-SIWUB: U5.H18; also elsewhere on the board
/FTDI2232H/U1-TXE#: U5.K17; also elsewhere on the board
/FTDI2232H/U1-WR#: U5.J16; also elsewhere on the board
/GPIOS/GPIO-N1: U5.K14; also elsewhere on the board
/GPIOS/GPIO-N2: U5.G13; also elsewhere on the board
/GPIOS/GPIO-N3: U5.H14; also elsewhere on the board
/GPIOS/GPIO-N4: U5.H16; also elsewhere on the board
/GPIOS/GPIO-N6: U5.G14; also elsewhere on the board
/GPIOS/GPIO-N7: U5.G18; also elsewhere on the board
/GPIOS/GPIO-N8: U5.F16; also elsewhere on the board
/GPIOS/GPIO-N9: U5.F18; also elsewhere on the board
/GPIOS/GPIO-N10: U5.E18; also elsewhere on the board
/GPIOS/GPIO-N11: U5.D18; also elsewhere on the board
/GPIOS/GPIO-N12: U5.C18; also elsewhere on the board
/GPIOS/GPIO-N13: U5.K13; also elsewhere on the board
/GPIOS/GPIO-N20: U5.M13; also elsewhere on the board
/GPIOS/GPIO-N21: U5.K16; also elsewhere on the board
/GPIOS/GPIO-N22: U5.N14; also elsewhere on the board
/GPIOS/GPIO-N23: U5.N16; also elsewhere on the board
/GPIOS/GPIO-N24: U5.L16; also elsewhere on the board
/GPIOS/GPIO-N25: U5.P16; also elsewhere on the board
/GPIOS/GPIO-N26: U5.L13; also elsewhere on the board
/GPIOS/GPIO-N27: U5.T18; also elsewhere on the board
/GPIOS/GPIO-N28: U5.U18; also elsewhere on the board
/GPIOS/GPIO-N29: U5.A16; also elsewhere on the board
/GPIOS/GPIO-N30: U5.A15; also elsewhere on the board
/GPIOS/GPIO-N31: U5.C14; also elsewhere on the board
/GPIOS/GPIO-N32: U5.A14; also elsewhere on the board
/GPIOS/GPIO-N33: U5.E13; also elsewhere on the board
/GPIOS/GPIO-N34: U5.A13; also elsewhere on the board
/GPIOS/GPIO-N35: U5.E12; also elsewhere on the board
/GPIOS/GPIO-N36: U5.C12; also elsewhere on the board
/GPIOS/GPIO-N37: U5.A12; also elsewhere on the board
/GPIOS/GPIO-N38: U5.E11; also elsewhere on the board
/GPIOS/GPIO-N39: U5.F10; also elsewhere on the board
/GPIOS/GPIO-N40: U5.C11; also elsewhere on the board
/GPIOS/GPIO-N41: U5.A11; also elsewhere on the board
/GPIOS/GPIO-N42: U5.A10; also elsewhere on the board
/GPIOS/GPIO-N43: U5.F9; also elsewhere on the board
/GPIOS/GPIO-N44: U5.C9; also elsewhere on the board
/GPIOS/GPIO-N45: U5.A9; also elsewhere on the board
/GPIOS/GPIO-N46: U5.F8; also elsewhere on the board
/GPIOS/GPIO-N47: U5.E8; also elsewhere on the board
/GPIOS/GPIO-N48: U5.C8; also elsewhere on the board
/GPIOS/GPIO-N49: U5.A8; also elsewhere on the board
/GPIOS/GPIO-N50: U5.E6; also elsewhere on the board
/GPIOS/GPIO-N51: U5.A7; also elsewhere on the board
/GPIOS/GPIO-N52: U5.A6; also elsewhere on the board
/GPIOS/GPIO-N53: U5.C6; also elsewhere on the board
/GPIOS/GPIO-N54: U5.A5; also elsewhere on the board
/GPIOS/GPIO-N55: U5.A4; also elsewhere on the board
/GPIOS/GPIO-N56: U5.A3; also elsewhere on the board
/GPIOS/GPIO-N57: U5.A2; also elsewhere on the board
/GPIOS/GPIO-N58: U5.V16; also elsewhere on the board
/GPIOS/GPIO-N59: U5.V15; also elsewhere on the board
/GPIOS/GPIO-N60: U5.V14; also elsewhere on the board
/GPIOS/GPIO-N61: U5.V13; also elsewhere on the board
/GPIOS/GPIO-N62: U5.V12; also elsewhere on the board
/GPIOS/GPIO-N63: U5.N11; also elsewhere on the board
/GPIOS/GPIO-N64: U5.T11; also elsewhere on the board
/GPIOS/GPIO-N65: U5.V11; also elsewhere on the board
/GPIOS/GPIO-N66: U5.P11; also elsewhere on the board
/GPIOS/GPIO-N67: U5.N9; also elsewhere on the board
/GPIOS/GPIO-N68: U5.T10; also elsewhere on the board
/GPIOS/GPIO-N69: U5.T8; also elsewhere on the board
/GPIOS/GPIO-N70: U5.V9; also elsewhere on the board
/GPIOS/GPIO-N71: U5.N8; also elsewhere on the board
/GPIOS/GPIO-N72: U5.P8; also elsewhere on the board
/GPIOS/GPIO-N73: U5.V8; also elsewhere on the board
/GPIOS/GPIO-N74: U5.P7; also elsewhere on the board
/GPIOS/GPIO-N75: U5.V7; also elsewhere on the board
/GPIOS/GPIO-N76: U5.T7; also elsewhere on the board
/GPIOS/GPIO-N77: U5.V6; also elsewhere on the board
/GPIOS/GPIO-N78: U5.P6; also elsewhere on the board
/GPIOS/GPIO-N79: U5.T5; also elsewhere on the board
/GPIOS/GPIO-N80: U5.V5; also elsewhere on the board
/GPIOS/GPIO-N81: U5.V4; also elsewhere on the board
/GPIOS/GPIO-N82: U5.T3; also elsewhere on the board
/GPIOS/GPIO-P1: U5.J13; also elsewhere on the board
/GPIOS/GPIO-P2: U5.H12; also elsewhere on the board
/GPIOS/GPIO-P3: U5.H13; also elsewhere on the board
/GPIOS/GPIO-P4: U5.H15; also elsewhere on the board
/GPIOS/GPIO-P6: U5.F14; also elsewhere on the board
/GPIOS/GPIO-P7: U5.G16; also elsewhere on the board
/GPIOS/GPIO-P8: U5.F15; also elsewhere on the board
/GPIOS/GPIO-P9: U5.F17; also elsewhere on the board
/GPIOS/GPIO-P10: U5.E16; also elsewhere on the board
/GPIOS/GPIO-P11: U5.D17; also elsewhere on the board
/GPIOS/GPIO-P12: U5.C17; also elsewhere on the board
/GPIOS/GPIO-P13: U5.K12; also elsewhere on the board
/GPIOS/GPIO-P20: U5.L14; also elsewhere on the board
/GPIOS/GPIO-P21: U5.K15; also elsewhere on the board
/GPIOS/GPIO-P22: U5.M14; also elsewhere on the board
/GPIOS/GPIO-P23: U5.N15; also elsewhere on the board
/GPIOS/GPIO-P24: U5.L15; also elsewhere on the board
/GPIOS/GPIO-P25: U5.P15; also elsewhere on the board
/GPIOS/GPIO-P26: U5.L12; also elsewhere on the board
/GPIOS/GPIO-P27: U5.T17; also elsewhere on the board
/GPIOS/GPIO-P28: U5.U17; also elsewhere on the board
/GPIOS/GPIO-P29: U5.B16; also elsewhere on the board
/GPIOS/GPIO-P30: U5.C15; also elsewhere on the board
/GPIOS/GPIO-P31: U5.D14; also elsewhere on the board
/GPIOS/GPIO-P32: U5.B14; also elsewhere on the board
/GPIOS/GPIO-P33: U5.F13; also elsewhere on the board
/GPIOS/GPIO-P34: U5.C13; also elsewhere on the board
/GPIOS/GPIO-P35: U5.F12; also elsewhere on the board
/GPIOS/GPIO-P36: U5.D12; also elsewhere on the board
/GPIOS/GPIO-P37: U5.B12; also elsewhere on the board
/GPIOS/GPIO-P38: U5.F11; also elsewhere on the board
/GPIOS/GPIO-P39: U5.G11; also elsewhere on the board
/GPIOS/GPIO-P40: U5.D11; also elsewhere on the board
/GPIOS/GPIO-P41: U5.B11; also elsewhere on the board
/GPIOS/GPIO-P42: U5.C10; also elsewhere on the board
/GPIOS/GPIO-P43: U5.G9; also elsewhere on the board
/GPIOS/GPIO-P44: U5.D9; also elsewhere on the board
/GPIOS/GPIO-P45: U5.B9; also elsewhere on the board
/GPIOS/GPIO-P46: U5.G8; also elsewhere on the board
/GPIOS/GPIO-P47: U5.E7; also elsewhere on the board
/GPIOS/GPIO-P48: U5.D8; also elsewhere on the board
/GPIOS/GPIO-P49: U5.B8; also elsewhere on the board
/GPIOS/GPIO-P50: U5.F7; also elsewhere on the board
/GPIOS/GPIO-P51: U5.C7; also elsewhere on the board
/GPIOS/GPIO-P52: U5.B6; also elsewhere on the board
/GPIOS/GPIO-P53: U5.D6; also elsewhere on the board
/GPIOS/GPIO-P54: U5.C5; also elsewhere on the board
/GPIOS/GPIO-P55: U5.B4; also elsewhere on the board
/GPIOS/GPIO-P56: U5.B3; also elsewhere on the board
/GPIOS/GPIO-P57: U5.B2; also elsewhere on the board
/GPIOS/GPIO-P58: U5.U16; also elsewhere on the board
/GPIOS/GPIO-P59: U5.U15; also elsewhere on the board
/GPIOS/GPIO-P60: U5.T14; also elsewhere on the board
/GPIOS/GPIO-P61: U5.U13; also elsewhere on the board
/GPIOS/GPIO-P62: U5.T12; also elsewhere on the board
/GPIOS/GPIO-P63: U5.M11; also elsewhere on the board
/GPIOS/GPIO-P64: U5.R11; also elsewhere on the board
/GPIOS/GPIO-P65: U5.U11; also elsewhere on the board
/GPIOS/GPIO-P66: U5.N10; also elsewhere on the board
/GPIOS/GPIO-P67: U5.M10; also elsewhere on the board
/GPIOS/GPIO-P68: U5.R10; also elsewhere on the board
/GPIOS/GPIO-P69: U5.R8; also elsewhere on the board
/GPIOS/GPIO-P70: U5.T9; also elsewhere on the board
/GPIOS/GPIO-P71: U5.M8; also elsewhere on the board
/GPIOS/GPIO-P72: U5.N7; also elsewhere on the board
/GPIOS/GPIO-P73: U5.U8; also elsewhere on the board
/GPIOS/GPIO-P74: U5.N6; also elsewhere on the board
/GPIOS/GPIO-P75: U5.U7; also elsewhere on the board
/GPIOS/GPIO-P76: U5.R7; also elsewhere on the board
/GPIOS/GPIO-P77: U5.T6; also elsewhere on the board
/GPIOS/GPIO-P78: U5.N5; also elsewhere on the board
/GPIOS/GPIO-P79: U5.R5; also elsewhere on the board
/GPIOS/GPIO-P80: U5.U5; also elsewhere on the board
/GPIOS/GPIO-P81: U5.T4; also elsewhere on the board
/GPIOS/GPIO-P82: U5.R3; also elsewhere on the board
/GPIOS/INITB: R17.1, U5.U3; also elsewhere on the board
/RAM/DDR-A0: U5.J7; also elsewhere on the board
/RAM/DDR-A1: U5.J6; also elsewhere on the board
/RAM/DDR-A2: U5.H5; also elsewhere on the board
/RAM/DDR-A3: U5.L7; also elsewhere on the board
/RAM/DDR-A4: U5.F3; also elsewhere on the board
/RAM/DDR-A5: U5.H4; also elsewhere on the board
/RAM/DDR-A6: U5.H3; also elsewhere on the board
/RAM/DDR-A7: U5.H6; also elsewhere on the board
/RAM/DDR-A8: U5.D2; also elsewhere on the board
/RAM/DDR-A9: U5.D1; also elsewhere on the board
/RAM/DDR-A10: U5.F4; also elsewhere on the board
/RAM/DDR-A11: U5.D3; also elsewhere on the board
/RAM/DDR-A12: U5.G6; also elsewhere on the board
/RAM/DDR-BA0: U5.F2; also elsewhere on the board
/RAM/DDR-BA1: U5.F1; also elsewhere on the board
/RAM/DDR-CAS: U5.K5; also elsewhere on the board
/RAM/DDR-CKE: U5.H7; also elsewhere on the board
/RAM/DDR-CK_N: U5.G1; also elsewhere on the board
/RAM/DDR-CK_P: U5.G3; also elsewhere on the board
/RAM/DDR-D0: U5.L2; also elsewhere on the board
/RAM/DDR-D1: U5.L1; also elsewhere on the board
/RAM/DDR-D2: U5.K2; also elsewhere on the board
/RAM/DDR-D3: U5.K1; also elsewhere on the board
/RAM/DDR-D4: U5.H2; also elsewhere on the board
/RAM/DDR-D5: U5.H1; also elsewhere on the board
/RAM/DDR-D6: U5.J3; also elsewhere on the board
/RAM/DDR-D7: U5.J1; also elsewhere on the board
/RAM/DDR-D8: U5.M3; also elsewhere on the board
/RAM/DDR-D9: U5.M1; also elsewhere on the board
/RAM/DDR-D10: U5.N2; also elsewhere on the board
/RAM/DDR-D11: U5.N1; also elsewhere on the board
/RAM/DDR-D12: U5.T2; also elsewhere on the board
/RAM/DDR-D13: U5.T1; also elsewhere on the board
/RAM/DDR-D14: U5.U2; also elsewhere on the board
/RAM/DDR-D15: U5.U1; also elsewhere on the board
/RAM/DDR-LDM: U5.K3; also elsewhere on the board
/RAM/DDR-LDQS: U5.L4; also elsewhere on the board
/RAM/DDR-RAS: U5.L5; also elsewhere on the board
/RAM/DDR-UDM: U5.K4; also elsewhere on the board
/RAM/DDR-UDQS: U5.P2; also elsewhere on the board
/RAM/DDR-WE: U5.E3; also elsewhere on the board
/RAM/RZQ: U5.N4; also elsewhere on the board
/SPARTAN6/DONE: R18.1, U5.V17
/SPARTAN6/GCLK1: C83.1, U5.V10, U10.3 (OUT)
/SPARTAN6/GCLK2: C16.1, U4.3 (OUT), U5.H17
/SPARTAN6/HSWAP: R14.2, U5.D4
/SPARTAN6/M0: GS6.1 (G1), R16.2, U5.T15
/SPARTAN6/M1: GS7.1 (G1), R15.2, U5.N12
/SPARTAN6/SUSPEND: GS5.1 (G1), U5.R16
DDR1V8: C43.1, C45.1, C47.1, C49.1, C51.1, C53.1, U5.E2, U5.G4, U5.J2, U5.J5, U5.M4, U5.R2; also elsewhere on the board
GND: C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C63.2, C64.2, C83.2, C84.2, GS5.2 (G2), GS6.2 (G2), GS7.2 (G2), P1.1, P1.3, P1.5, P1.7, P1.9, P1.11, P1.13, U4.2 (GND), U5.A1, U5.A18, U5.B7, U5.B13, U5.C3, U5.C16, U5.D5, U5.D10, U5.E15, U5.G2, U5.G5, U5.G12, U5.G17, U5.H8, U5.H10, U5.J4, U5.J9, U5.J11, U5.J15, U5.K8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; also elsewhere on the board
unnamed: R31.2, U5.A17
unnamed: R34.2, U5.D16
unnamed: R32.2, U5.D15
unnamed: R33.2, U5.B18
unnamed: D1.2 (K), R18.2
VCC1V2: C18.1, C20.1, C22.1, C24.1, C26.1, C28.1, C30.1, C32.1, C34.1, C36.1, C38.1, U5.G7, U5.H9, U5.H11, U5.J8, U5.J10, U5.K9, U5.K11, U5.L8, U5.L10, U5.M7, U5.M12; also elsewhere on the board
VCC3V3: C17.1, C19.1, C21.1, C23.1, C25.1, C27.1, C29.1, C31.1, C33.1, C35.1, C37.1, C39.1, C40.1, C41.1, C42.1, C44.1, C46.1, C48.1, C50.1, C52.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C63.1, C64.1, C84.1, D1.1 (A), P1.2, R14.1, R15.1, R16.1, R17.2, R19.2, U4.1 (E/D), U4.4 (VCC), U5.B1, U5.B5, U5.B10, U5.B15, U5.B17, U5.D7, U5.D13, U5.E5, U5.E9, U5.E10, U5.E14, U5.E17, U5.G10, U5.G15, U5.J12, U5.J14, U5.J17, U5.K7, U5.M9, U5.M15, U5.P5, U5.P9, U5.P10, U5.P14, U5.R6, U5.R12, U5.R17, U5.U4, U5.U9, U5.U14, U10.1 (E/D), U10.4 (VCC); also elsewhere on the board

Notes on the sheet:
MISC
BANK 3
BANK 2
BANK 1
BANK 0
JTAG
100MHz OSCILLATOR
NOT POPULATED

Parts:
C1, C2, C3, C4, C5, C7, C8, C10, C11, C12, C13, C14, C15: 0.1uF
C6, C9: 22pF
L1, L2: INDUCTOR
P10, P11: CONN_3X2
Q1: NPN
R1, R3, R7, R10, R11, R13, R30, R35, R36, R37, R38: 10K
R2: 2K2
R4, R8, R9, R12: 0R
R5: 12K
R6: 4K7
R39: 2.2K
U1: 93LC46
U2: FT2232H
U3: M25P16
U11: 74LVC1GU04
VR1, VR2: VR
X1: USBMINI
X2: CRYSTAL

Connections:
/FTDI2232H/DM: U2.7 (DM), VR1.1, X1.2 (D-)
/FTDI2232H/DP: U2.8 (DP), VR2.1, X1.3 (D+)
/FTDI2232H/EEDATA: R2.1, U1.3 (DI), U2.61 (EEDATA)
/FTDI2232H/FTDI-AC0: U2.26 (ACBUS0); also elsewhere on the board
/FTDI2232H/FTDI-AC1: U2.27 (ACBUS1); also elsewhere on the board
/FTDI2232H/FTDI-AC2: U2.28 (ACBUS2); also elsewhere on the board
/FTDI2232H/FTDI-AC3: U2.29 (ACBUS3); also elsewhere on the board
/FTDI2232H/FTDI-AC4: U2.30 (ACBUS4); also elsewhere on the board
/FTDI2232H/FTDI-AC5: U2.32 (ACBUS5); also elsewhere on the board
/FTDI2232H/FTDI-AC6: U2.33 (ACBUS6); also elsewhere on the board
/FTDI2232H/FTDI-AC7: U2.34 (ACBUS7); also elsewhere on the board
/FTDI2232H/PROGB: Q1.3 (C), R39.2, U11.4 (Y); also elsewhere on the board
/FTDI2232H/TCK: P11.4; also elsewhere on the board
/FTDI2232H/TCK/SCK: P11.2, U2.16 (ADBUS0)
/FTDI2232H/TDI: P10.3; also elsewhere on the board
/FTDI2232H/TDI/SDO: P10.5, U2.17 (ADBUS1)
/FTDI2232H/TDO: P10.4; also elsewhere on the board
/FTDI2232H/TDO/SDI: P10.2, U2.18 (ADBUS2)
/FTDI2232H/TMS: P11.3; also elsewhere on the board
/FTDI2232H/TMS/CS: P11.5, U2.19 (ADBUS3)
/FTDI2232H/U1-CS: P11.6, R8.1; also elsewhere on the board
/FTDI2232H/U1-D0: U2.38 (BDBUS0); also elsewhere on the board
/FTDI2232H/U1-D1: U2.39 (BDBUS1); also elsewhere on the board
/FTDI2232H/U1-D2: U2.40 (BDBUS2); also elsewhere on the board
/FTDI2232H/U1-D3: U2.41 (BDBUS3); also elsewhere on the board
/FTDI2232H/U1-D4: U2.43 (BDBUS4); also elsewhere on the board
/FTDI2232H/U1-D5: U2.44 (BDBUS5); also elsewhere on the board
/FTDI2232H/U1-D6: U2.45 (BDBUS6); also elsewhere on the board
/FTDI2232H/U1-D7: U2.46 (BDBUS7); also elsewhere on the board
/FTDI2232H/U1-RD#: U2.53 (BCBUS2); also elsewhere on the board
/FTDI2232H/U1-RXF#: U2.48 (BCBUS0); also elsewhere on the board
/FTDI2232H/U1-SCK: P11.1, R4.2; also elsewhere on the board
/FTDI2232H/U1-SDI: P10.1, R3.2, R9.1; also elsewhere on the board
/FTDI2232H/U1-SDO: P10.6, R12.2, R30.2; also elsewhere on the board
/FTDI2232H/U1-SIWUB: U2.55 (BCBUS4); also elsewhere on the board
/FTDI2232H/U1-TXE#: U2.52 (BCBUS1); also elsewhere on the board
/FTDI2232H/U1-WR#: U2.54 (BCBUS3); also elsewhere on the board
/FTDI2232H/VCC1V8: C1.1, C2.1, C3.1, C4.1, U2.12 (VCORE), U2.37 (VCORE), U2.49 (VREGOUT), U2.64 (VCORE)
/FTDI2232H/VPHY: C13.1, L1.2, U2.4 (VPHY)
/FTDI2232H/VPLL: C14.1, L2.2, U2.9 (VPLL)
/FTDI2232H/~RESET: R6.2, R7.2, U2.14 (~RESET)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.1, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, Q1.1 (E), R5.2, R7.1, R36.1, U1.2 (GND), U2.1 (GND), U2.5 (GND), U2.10 (AGND), U2.11 (GND), U2.13 (TEST), U2.15 (GND), U2.25 (GND), U2.35 (GND), U2.47 (GND), U2.51 (GND), U3.4 (VSS), U11.3 (GND), VR1.2, VR2.2, X1.0, X1.5 (GND); also elsewhere on the board
unnamed: R13.1, U3.7 (~HOLD)
unnamed: R9.2, U3.2 (Q)
unnamed: R12.1, U3.5 (D)
unnamed: R8.2, R11.1, U3.1 (~S)
unnamed: R10.1, U3.3 (~W)
unnamed: R4.1, U3.6 (C)
unnamed: R35.2, R36.2, U2.24 (ADBUS7), U11.2 (A)
unnamed: C9.2, U2.3 (OSCO), X2.1
unnamed: R37.1, U1.5 (CS), U2.63 (EECS)
unnamed: R1.1, R2.2, U1.1 (DO)
unnamed: C6.2, U2.2 (OSCI), X2.2
unnamed: Q1.2 (B), R35.1
unnamed: R38.1, U1.4 (CLK), U2.62 (EECLK)
unnamed: R5.1, U2.6 (REF)
VBUS: X1.1 (VUSB); also elsewhere on the board
VCC3V3: C5.1, C7.1, C8.1, C10.1, C11.1, C12.2, C15.1, L1.1, L2.1, R1.2, R3.1, R6.1, R10.2, R11.2, R13.2, R30.1, R37.2, R38.2, R39.1, U1.6 (VCC), U2.20 (VCCIO), U2.31 (VCCIO), U2.42 (VCCIO), U2.50 (VREGIN), U2.56 (VCCIO), U3.8 (VCC), U11.5 (VCC); also elsewhere on the board

Notes on the sheet:
EEPROM FOR FT2232H
USB
12MHz
NOT POPULATED
SPI FLASH
Jumper on - J1,J2,J3,J4 - JTAG COMMUNICATION Jumper on - S1,S2,S3,S4 - SPI COMMUNICATION

Board: 6 copper layers, 62.8 x 57.5 mm, 157 parts (0 on the bottom side), 271 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; MH-3.2MM
