# Repository numato/samplecode

## KiCad design FPGA/Mimas/board/Mimas.kicad_pcb

Board: 2 copper layers, 66.1 x 62.2 mm, 94 parts (53 on the bottom side), 138 nets.

Parts:
C1: 47MFD; SM1210
C2, C3, C4: 10MFD; SM0805
C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C30, C32: .01MFD; SM0603_Capa
C26: .01uf; SM0603_Capa
C27: 15pf; SM0603_Capa
C28, C29: 22PF; SM0603_Capa
C31: 0.1ufd; SM0603_Capa
C33: 0.1ufd; SM0805
D1, D2, D3, D4, D5, D6, D7, D8, D9: LED; LED-0805
GS1, GS2: GS3
GS3, GS4, GS5: GS2
P1, P5: CONN_2; PIN_ARRAY_2X1
P2, P3: CONN_20X2; PIN_ARRAY_20X2
P4: CONN_3X2; pin_array_3x2
P6: CONN_6; PIN_ARRAY-6X1
R1, R2, R4, R6: 220; SM0603
R3: 10; SM0603
R5, R7: 330; SM0603
R8, R9: RES_NET4
R10, R14, R15: 4.7K; SM0603
R11, R13, R16, R19, R20, R21, R22, R25, R26: 10K; SM0603
R12: 1K; SM0603
R17, R18, R23, R24: 100R; SM0603
SW1, SW2, SW3, SW4: SW_PUSH; Switch_SMD
U1, U2: LM317_SOT223; SOT223
U3: LM317_SOT223; DPAK2
U4: XC6SLX9-2TQG144C; TQG144
U5: FXO-HC536R
U6: PIC18F14K50; SSOP-20
U7: M25P16; SO8
VR1, VR2: VR; SM0603
X1: USBMINI; USBMICRO
X2: CRYSTAL; HC-49V

Connections:
/Gpios/GPIO-N1: P2.3, U4.131
/Gpios/GPIO-N2: P2.5, U4.133
/Gpios/GPIO-N3: P2.7, U4.137
/Gpios/GPIO-N4: P2.9, U4.139
/Gpios/GPIO-N5: P2.11, U4.141
/Gpios/GPIO-N6: P2.13, U4.1
/Gpios/GPIO-N7: P2.15, U4.5
/Gpios/GPIO-N8: P2.17, U4.7
/Gpios/GPIO-N9: P2.19, U4.9
/Gpios/GPIO-N10: P2.21, U4.11
/Gpios/GPIO-N11: P2.23, U4.14
/Gpios/GPIO-N12: P2.25, U4.16
/Gpios/GPIO-N13: P2.27, U4.21
/Gpios/GPIO-N14: P2.29, U4.23
/Gpios/GPIO-N15: P2.31, U4.26
/Gpios/GPIO-N16: P2.33, U4.29
/Gpios/GPIO-N17: P2.35, U4.32
/Gpios/GPIO-N18: P2.37, U4.34
/Gpios/GPIO-N19: P3.30, U4.55
/Gpios/GPIO-N22: P3.32, U4.50
/Gpios/GPIO-N24: P3.34, U4.47
/Gpios/GPIO-N26: P3.28, U4.74
/Gpios/GPIO-N27: P3.26, U4.78
/Gpios/GPIO-N28: P3.24, U4.80
/Gpios/GPIO-N29: P3.20, U4.82
/Gpios/GPIO-N30: P3.18, U4.84
/Gpios/GPIO-N31: P3.16, U4.87
/Gpios/GPIO-N32: P3.14, U4.92
/Gpios/GPIO-N33: P3.12, U4.94
/Gpios/GPIO-N34: P3.10, U4.97
/Gpios/GPIO-N35: P3.8, U4.99
/Gpios/GPIO-N36: P3.6, U4.101
/Gpios/GPIO-N37: P3.4, U4.104
/Gpios/GPIO-N38: P3.38, U4.43
/Gpios/GPIO-N39: P3.36, U4.45
/Gpios/GPIO-P1: P2.4, U4.132
/Gpios/GPIO-P2: P2.6, U4.134
/Gpios/GPIO-P3: P2.8, U4.138
/Gpios/GPIO-P4: P2.10, U4.140
/Gpios/GPIO-P5: P2.12, U4.142
/Gpios/GPIO-P6: P2.14, U4.2
/Gpios/GPIO-P7: P2.16, U4.6
/Gpios/GPIO-P8: P2.18, U4.8
/Gpios/GPIO-P9: P2.20, U4.10
/Gpios/GPIO-P10: P2.22, U4.12
/Gpios/GPIO-P11: P2.24, U4.15
/Gpios/GPIO-P12: P2.26, U4.17
/Gpios/GPIO-P13: P2.28, U4.22
/Gpios/GPIO-P14: P2.30, U4.24
/Gpios/GPIO-P15: P2.32, U4.27
/Gpios/GPIO-P16: P2.34, U4.30
/Gpios/GPIO-P17: P2.36, U4.33
/Gpios/GPIO-P18: P2.38, U4.35
/Gpios/GPIO-P19: P3.29, U4.56
/Gpios/GPIO-P22: P3.31, U4.51
/Gpios/GPIO-P24: P3.33, U4.48
/Gpios/GPIO-P26: P3.27, U4.75
/Gpios/GPIO-P27: P3.25, U4.79
/Gpios/GPIO-P28: P3.23, U4.81
/Gpios/GPIO-P29: P3.19, U4.83
/Gpios/GPIO-P30: P3.17, U4.85
/Gpios/GPIO-P31: P3.15, U4.88
/Gpios/GPIO-P32: P3.13, U4.93
/Gpios/GPIO-P33: P3.11, U4.95
/Gpios/GPIO-P34: P3.9, U4.98
/Gpios/GPIO-P35: P3.7, U4.100
/Gpios/GPIO-P36: P3.5, U4.102
/Gpios/GPIO-P37: P3.3, U4.105
/Gpios/GPIO-P38: P3.37, U4.44
/Gpios/GPIO-P39: P3.35, U4.46
/Gpios/LED0: R8.7, U4.119
/Gpios/LED1: R8.5, U4.118
/Gpios/LED2: R8.3, U4.117
/Gpios/LED3: R8.1, U4.116
/Gpios/LED4: R9.7, U4.115
/Gpios/LED5: R9.5, U4.114
/Gpios/LED6: R9.3, U4.112
/Gpios/LED7: R9.1, U4.111
/Gpios/SW0: SW1.1, U4.124
/Gpios/SW1: SW2.1, U4.123
/Gpios/SW2: SW3.1, U4.121
/Gpios/SW3: SW4.1, U4.120
/Gpios/VCCIO: C3.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, P2.2, P2.40, P3.1, P3.39, R4.1, U2.2, U2.4, U4.4, U4.18, U4.31, U4.76, U4.86, U4.103, U4.122, U4.125, U4.135
/PIC18F14K50/CLK: U4.57, U6.16
/PIC18F14K50/D0: U4.61, U6.8
/PIC18F14K50/D1: U4.62, U6.7
/PIC18F14K50/D2: U4.67, U6.5
/PIC18F14K50/D3: U4.66, U6.6
/PIC18F14K50/DM: P6.2, U6.18, VR2.1, X1.2
/PIC18F14K50/DP: P6.3, U6.19, VR1.1, X1.3
/PIC18F14K50/MCLR: C33.1, P5.2, P6.6, R16.2, U6.4
/PIC18F14K50/OSC1: C29.1, U6.2, X2.2
/PIC18F14K50/OSC2: C28.1, U6.3, X2.1
/PIC18F14K50/PROGB: R14.2, U4.37, U6.15
/PIC18F14K50/RD: U4.59, U6.14
/PIC18F14K50/SCK: R23.2, R25.2, U4.70, U6.11
/PIC18F14K50/SCS: R17.1, U4.38, U6.12
/PIC18F14K50/SDI: R18.1, R26.2, U4.65, U6.13
/PIC18F14K50/SDO: R21.2, R24.2, U4.64, U6.9
/PIC18F14K50/VCCAUX: C4.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C31.2, C32.2, D9.1, P4.5, P6.5, R6.1, R10.1, R11.1, R13.1, R14.1, R15.1, R16.1, R19.1, R20.2, R21.1, R22.1, R25.1, R26.1, U3.2, U4.20, U4.36, U4.42, U4.53, U4.63, U4.90, U4.129, U5.1, U5.4, U6.1, U7.8
/PIC18F14K50/VUSB: GS1.1, X1.1
/PIC18F14K50/WR: U4.58, U6.10
/PowerSupply/VCCIN: C1.1, GS1.2, U1.3, U2.3, U3.3
/PowerSupply/VCCINT: C2.1, C5.1, C6.1, C7.1, C8.1, C9.1, R2.1, U1.2, U1.4, U4.19, U4.28, U4.52, U4.89, U4.128
/XC6SLX9/DONE: R12.1, U4.71
/XC6SLX9/GCLK: C27.1, U4.126, U5.3
/XC6SLX9/HSWAP: R10.2, U4.144
/XC6SLX9/INIT_B: R15.2, U4.39
/XC6SLX9/M0: GS5.1, R13.2, U4.69
/XC6SLX9/M1: GS4.1, R11.2, U4.60
/XC6SLX9/SUSPEND: GS3.1, U4.73
/XC6SLX9/TCK: P4.1, U4.109
/XC6SLX9/TDI: P4.2, U4.110
/XC6SLX9/TDO: P4.4, U4.106
/XC6SLX9/TMS: P4.6, U4.107
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.1, C32.1, C33.2, D1.2, D2.2, D3.2, D4.2, D5.2, D6.2, D7.2, D8.2, GS2.2, GS3.2, GS4.2, GS5.2, P1.1, P2.1, P2.39, P3.2, P3.21, P3.22, P3.40, P4.3, P5.1, P6.4, R3.2, R7.2, SW1.2, SW2.2, SW3.2, SW4.2, U4.3, U4.13, U4.25, U4.49, U4.54, U4.68, U4.77, U4.91, U4.96, U4.108, U4.113, U4.130, U4.136, U5.2, U6.20, U7.4, VR1.2, VR2.2, X1.0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
unnamed: GS1.3, P1.2
unnamed: R2.2, R3.1, U1.1
unnamed: GS2.3, R1.2
unnamed: GS2.1, R5.2
unnamed: R6.2, R7.1, U3.1
unnamed: R1.1, R4.2, R5.1, U2.1
unnamed: D9.2, R12.2
unnamed: R22.2, U7.7
unnamed: R24.1, U7.5
unnamed: R19.2, U7.3
unnamed: R23.1, U7.6
unnamed: R18.2, U7.2
unnamed: C30.1, U6.17
unnamed: R17.2, R20.1, U7.1
unnamed: D1.1, R8.8
unnamed: D2.1, R8.6
unnamed: D3.1, R8.4
unnamed: D4.1, R8.2
unnamed: D5.1, R9.8
unnamed: D6.1, R9.6
unnamed: D7.1, R9.4
unnamed: D8.1, R9.2

## KiCad design FPGA/Saturn/board/saturn.kicad_pcb

File FPGA/Saturn/board/readme.txt:

This folder contains schematics and layout files for Saturn Spartan6 FPGA module. You will need KiCad to open and edit this project.

Notes on the sheet:
FT2232H
POWER SUPPLY
LPDDR
GPIOs
SPARTAN 6 FPGA
CSG324

Parts:
C65: 47uF
C69, C70, C71: 10uF
C72, C73, C74: 0.1uF
J1: JACK_2P
K1: CONN_3
R20: 330R
R21: 0R
R22: 100R
R23, R24, R25: 220R
U6, U7, U8: LM1117

Connections:
DDR1V8: C69.1, C72.1, R25.1, U8.2 (OUT); also elsewhere on the board
GND: C65.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, J1.2, J1.3, R20.1, R21.1, R22.1; also elsewhere on the board
unnamed: R20.2, R23.2, U6.1 (ADJ)
unnamed: R21.2, R24.2, U7.1 (ADJ)
unnamed: R22.2, R25.2, U8.1 (ADJ)
unnamed: J1.1, K1.3
VBUS: K1.1; also elsewhere on the board
VCC1V2: C71.1, C74.1, R24.1, U7.2 (OUT); also elsewhere on the board
VCC3V3: C70.1, C73.1, R23.1, U6.2 (OUT); also elsewhere on the board
VCCIN: C65.1, K1.2 (PM), U6.3 (IN), U7.3 (IN), U8.3 (IN); also elsewhere on the board

Notes on the sheet:
EXTERNAL POWER
1 - 2 EXT PWR 2 - 3 USB PWR

Parts:
P2, P3, P4, P5, P6, P7, P8, P9: CONN_12X2

Connections:
/FTDI2232H/FTDI-AC0: P6.1; also elsewhere on the board
/FTDI2232H/FTDI-AC1: P6.2; also elsewhere on the board
/FTDI2232H/FTDI-AC2: P6.3; also elsewhere on the board
/FTDI2232H/FTDI-AC3: P6.4; also elsewhere on the board
/FTDI2232H/FTDI-AC4: P6.5; also elsewhere on the board
/FTDI2232H/FTDI-AC5: P6.6; also elsewhere on the board
/FTDI2232H/FTDI-AC6: P6.7; also elsewhere on the board
/FTDI2232H/FTDI-AC7: P6.8; also elsewhere on the board
/FTDI2232H/PROGB: P8.21; also elsewhere on the board
/GPIOS/GPIO-N1: P2.3; also elsewhere on the board
/GPIOS/GPIO-N2: P3.3; also elsewhere on the board
/GPIOS/GPIO-N3: P2.5; also elsewhere on the board
/GPIOS/GPIO-N4: P3.5; also elsewhere on the board
/GPIOS/GPIO-N6: P3.7; also elsewhere on the board
/GPIOS/GPIO-N7: P2.7; also elsewhere on the board
/GPIOS/GPIO-N8: P3.9; also elsewhere on the board
/GPIOS/GPIO-N9: P2.9; also elsewhere on the board
/GPIOS/GPIO-N10: P3.11; also elsewhere on the board
/GPIOS/GPIO-N11: P2.11; also elsewhere on the board
/GPIOS/GPIO-N12: P3.13; also elsewhere on the board
/GPIOS/GPIO-N13: P7.4; also elsewhere on the board
/GPIOS/GPIO-N20: P7.6; also elsewhere on the board
/GPIOS/GPIO-N21: P6.12; also elsewhere on the board
/GPIOS/GPIO-N22: P7.8; also elsewhere on the board
/GPIOS/GPIO-N23: P7.12; also elsewhere on the board
/GPIOS/GPIO-N24: P7.10; also elsewhere on the board
/GPIOS/GPIO-N25: P7.14; also elsewhere on the board
/GPIOS/GPIO-N26: P6.10; also elsewhere on the board
/GPIOS/GPIO-N27: P6.14; also elsewhere on the board
/GPIOS/GPIO-N28: P7.16; also elsewhere on the board
/GPIOS/GPIO-N29: P2.13; also elsewhere on the board
/GPIOS/GPIO-N30: P3.15; also elsewhere on the board
/GPIOS/GPIO-N31: P2.15; also elsewhere on the board
/GPIOS/GPIO-N32: P3.17; also elsewhere on the board
/GPIOS/GPIO-N33: P2.17; also elsewhere on the board
/GPIOS/GPIO-N34: P3.19; also elsewhere on the board
/GPIOS/GPIO-N35: P2.19; also elsewhere on the board
/GPIOS/GPIO-N36: P3.21; also elsewhere on the board
/GPIOS/GPIO-N37: P2.21; also elsewhere on the board
/GPIOS/GPIO-N38: P3.23; also elsewhere on the board
/GPIOS/GPIO-N39: P5.3; also elsewhere on the board
/GPIOS/GPIO-N40: P2.23; also elsewhere on the board
/GPIOS/GPIO-N41: P4.3; also elsewhere on the board
/GPIOS/GPIO-N42: P5.5; also elsewhere on the board
/GPIOS/GPIO-N43: P4.5; also elsewhere on the board
/GPIOS/GPIO-N44: P5.7; also elsewhere on the board
/GPIOS/GPIO-N45: P4.7; also elsewhere on the board
/GPIOS/GPIO-N46: P5.9; also elsewhere on the board
/GPIOS/GPIO-N47: P4.9; also elsewhere on the board
/GPIOS/GPIO-N48: P5.11; also elsewhere on the board
/GPIOS/GPIO-N49: P4.11; also elsewhere on the board
/GPIOS/GPIO-N50: P5.13; also elsewhere on the board
/GPIOS/GPIO-N51: P4.13; also elsewhere on the board
/GPIOS/GPIO-N52: P5.15; also elsewhere on the board
/GPIOS/GPIO-N53: P4.15; also elsewhere on the board
/GPIOS/GPIO-N54: P5.17; also elsewhere on the board
/GPIOS/GPIO-N55: P4.17; also elsewhere on the board
/GPIOS/GPIO-N56: P5.19; also elsewhere on the board
/GPIOS/GPIO-N57: P4.19; also elsewhere on the board
/GPIOS/GPIO-N58: P6.16; also elsewhere on the board
/GPIOS/GPIO-N59: P7.18; also elsewhere on the board
/GPIOS/GPIO-N60: P6.18; also elsewhere on the board
/GPIOS/GPIO-N61: P7.20; also elsewhere on the board
/GPIOS/GPIO-N62: P6.20; also elsewhere on the board
/GPIOS/GPIO-N63: P7.22; also elsewhere on the board
/GPIOS/GPIO-N64: P6.22; also elsewhere on the board
/GPIOS/GPIO-N65: P8.4; also elsewhere on the board
/GPIOS/GPIO-N66: P9.4; also elsewhere on the board
/GPIOS/GPIO-N67: P8.6; also elsewhere on the board
/GPIOS/GPIO-N68: P9.6; also elsewhere on the board
/GPIOS/GPIO-N69: P8.8; also elsewhere on the board
/GPIOS/GPIO-N70: P9.8; also elsewhere on the board
/GPIOS/GPIO-N71: P8.10; also elsewhere on the board
/GPIOS/GPIO-N72: P9.10; also elsewhere on the board
/GPIOS/GPIO-N73: P8.12; also elsewhere on the board
/GPIOS/GPIO-N74: P8.14; also elsewhere on the board
/GPIOS/GPIO-N75: P9.12; also elsewhere on the board
/GPIOS/GPIO-N76: P9.14; also elsewhere on the board
/GPIOS/GPIO-N77: P8.16; also elsewhere on the board
/GPIOS/GPIO-N78: P9.16; also elsewhere on the board
/GPIOS/GPIO-N79: P9.18; also elsewhere on the board
/GPIOS/GPIO-N80: P8.18; also elsewhere on the board
/GPIOS/GPIO-N81: P8.20; also elsewhere on the board
/GPIOS/GPIO-N82: P9.20; also elsewhere on the board
/GPIOS/GPIO-P1: P2.4; also elsewhere on the board
/GPIOS/GPIO-P2: P3.4; also elsewhere on the board
/GPIOS/GPIO-P3: P2.6; also elsewhere on the board
/GPIOS/GPIO-P4: P3.6; also elsewhere on the board
/GPIOS/GPIO-P6: P3.8; also elsewhere on the board
/GPIOS/GPIO-P7: P2.8; also elsewhere on the board
/GPIOS/GPIO-P8: P3.10; also elsewhere on the board
/GPIOS/GPIO-P9: P2.10; also elsewhere on the board
/GPIOS/GPIO-P10: P3.12; also elsewhere on the board
/GPIOS/GPIO-P11: P2.12; also elsewhere on the board
/GPIOS/GPIO-P12: P3.14; also elsewhere on the board
/GPIOS/GPIO-P13: P7.3; also elsewhere on the board
/GPIOS/GPIO-P20: P7.5; also elsewhere on the board
/GPIOS/GPIO-P21: P6.11; also elsewhere on the board
/GPIOS/GPIO-P22: P7.7; also elsewhere on the board
/GPIOS/GPIO-P23: P7.11; also elsewhere on the board
/GPIOS/GPIO-P24: P7.9; also elsewhere on the board
/GPIOS/GPIO-P25: P7.13; also elsewhere on the board
/GPIOS/GPIO-P26: P6.9; also elsewhere on the board
/GPIOS/GPIO-P27: P6.13; also elsewhere on the board
/GPIOS/GPIO-P28: P7.15; also elsewhere on the board
/GPIOS/GPIO-P29: P2.14; also elsewhere on the board
/GPIOS/GPIO-P30: P3.16; also elsewhere on the board
/GPIOS/GPIO-P31: P2.16; also elsewhere on the board
/GPIOS/GPIO-P32: P3.18; also elsewhere on the board
/GPIOS/GPIO-P33: P2.18; also elsewhere on the board
/GPIOS/GPIO-P34: P3.20; also elsewhere on the board
/GPIOS/GPIO-P35: P2.20; also elsewhere on the board
/GPIOS/GPIO-P36: P3.22; also elsewhere on the board
/GPIOS/GPIO-P37: P2.22; also elsewhere on the board
/GPIOS/GPIO-P38: P3.24; also elsewhere on the board
/GPIOS/GPIO-P39: P5.4; also elsewhere on the board
/GPIOS/GPIO-P40: P2.24; also elsewhere on the board
/GPIOS/GPIO-P41: P4.4; also elsewhere on the board
/GPIOS/GPIO-P42: P5.6; also elsewhere on the board
/GPIOS/GPIO-P43: P4.6; also elsewhere on the board
/GPIOS/GPIO-P44: P5.8; also elsewhere on the board
/GPIOS/GPIO-P45: P4.8; also elsewhere on the board
/GPIOS/GPIO-P46: P5.10; also elsewhere on the board
/GPIOS/GPIO-P47: P4.10; also elsewhere on the board
/GPIOS/GPIO-P48: P5.12; also elsewhere on the board
/GPIOS/GPIO-P49: P4.12; also elsewhere on the board
/GPIOS/GPIO-P50: P5.14; also elsewhere on the board
/GPIOS/GPIO-P51: P4.14; also elsewhere on the board
/GPIOS/GPIO-P52: P5.16; also elsewhere on the board
/GPIOS/GPIO-P53: P4.16; also elsewhere on the board
/GPIOS/GPIO-P54: P5.18; also elsewhere on the board
/GPIOS/GPIO-P55: P4.18; also elsewhere on the board
/GPIOS/GPIO-P56: P5.20; also elsewhere on the board
/GPIOS/GPIO-P57: P4.20; also elsewhere on the board
/GPIOS/GPIO-P58: P6.15; also elsewhere on the board
/GPIOS/GPIO-P59: P7.17; also elsewhere on the board
/GPIOS/GPIO-P60: P6.17; also elsewhere on the board
/GPIOS/GPIO-P61: P7.19; also elsewhere on the board
/GPIOS/GPIO-P62: P6.19; also elsewhere on the board
/GPIOS/GPIO-P63: P7.21; also elsewhere on the board
/GPIOS/GPIO-P64: P6.21; also elsewhere on the board
/GPIOS/GPIO-P65: P8.3; also elsewhere on the board
/GPIOS/GPIO-P66: P9.3; also elsewhere on the board
/GPIOS/GPIO-P67: P8.5; also elsewhere on the board
/GPIOS/GPIO-P68: P9.5; also elsewhere on the board
/GPIOS/GPIO-P69: P8.7; also elsewhere on the board
/GPIOS/GPIO-P70: P9.7; also elsewhere on the board
/GPIOS/GPIO-P71: P8.9; also elsewhere on the board
/GPIOS/GPIO-P72: P9.9; also elsewhere on the board
/GPIOS/GPIO-P73: P8.11; also elsewhere on the board
/GPIOS/GPIO-P74: P8.13; also elsewhere on the board
/GPIOS/GPIO-P75: P9.11; also elsewhere on the board
/GPIOS/GPIO-P76: P9.13; also elsewhere on the board
/GPIOS/GPIO-P77: P8.15; also elsewhere on the board
/GPIOS/GPIO-P78: P9.15; also elsewhere on the board
/GPIOS/GPIO-P79: P9.17; also elsewhere on the board
/GPIOS/GPIO-P80: P8.17; also elsewhere on the board
/GPIOS/GPIO-P81: P8.19; also elsewhere on the board
/GPIOS/GPIO-P82: P9.19; also elsewhere on the board
/GPIOS/INITB: P9.21; also elsewhere on the board
GND: P2.2, P3.1, P4.1, P4.2, P4.21, P4.22, P5.1, P5.2, P5.21, P5.22, P6.23, P6.24, P7.2, P7.23, P7.24, P8.1, P8.2, P8.23, P8.24, P9.1, P9.2, P9.23, P9.24; also elsewhere on the board
VCC3V3: P3.2, P4.23, P4.24, P5.23, P5.24, P7.1, P8.22, P9.22; also elsewhere on the board
VCCIN: P2.1; also elsewhere on the board

Notes on the sheet:
100
101
102
103
104
105
106
107
108
109
110
111
112
113
114
115
116
117
118
119
120
121
122
123
124
125
126
127
128
129
130
131
132
133
134
135
136
137
138
139

Parts:
C75, C76, C77, C78, C79, C80, C81, C82: 0.1uF
R26, R27, R29: 100R
R28: 4.7K
U9: MT46H32M16LF

Connections:
/RAM/DDR-A0: U9.J8 (A0); also elsewhere on the board
/RAM/DDR-A1: U9.J9 (A1); also elsewhere on the board
/RAM/DDR-A2: U9.K7 (A2); also elsewhere on the board
/RAM/DDR-A3: U9.K8 (A3); also elsewhere on the board
/RAM/DDR-A4: U9.K2 (A4); also elsewhere on the board
/RAM/DDR-A5: U9.K3 (A5); also elsewhere on the board
/RAM/DDR-A6: U9.J1 (A6); also elsewhere on the board
/RAM/DDR-A7: U9.J2 (A7); also elsewhere on the board
/RAM/DDR-A8: U9.J3 (A8); also elsewhere on the board
/RAM/DDR-A9: U9.H1 (A9); also elsewhere on the board
/RAM/DDR-A10: U9.J7 (A10); also elsewhere on the board
/RAM/DDR-A11: U9.H2 (A11); also elsewhere on the board
/RAM/DDR-A12: U9.H3 (A12); also elsewhere on the board
/RAM/DDR-BA0: U9.H8 (BA0); also elsewhere on the board
/RAM/DDR-BA1: U9.H9 (BA1); also elsewhere on the board
/RAM/DDR-CAS: U9.G8 (CAS#); also elsewhere on the board
/RAM/DDR-CKE: R28.1, U9.G1 (CKE); also elsewhere on the board
/RAM/DDR-CK_N: R27.2, U9.G3 (CK#); also elsewhere on the board
/RAM/DDR-CK_P: R27.1, U9.G2 (CK); also elsewhere on the board
/RAM/DDR-D0: U9.A8 (DQ0); also elsewhere on the board
/RAM/DDR-D1: U9.B7 (DQ1); also elsewhere on the board
/RAM/DDR-D2: U9.B8 (DQ2); also elsewhere on the board
/RAM/DDR-D3: U9.C7 (DQ3); also elsewhere on the board
/RAM/DDR-D4: U9.C8 (DQ4); also elsewhere on the board
/RAM/DDR-D5: U9.D7 (DQ5); also elsewhere on the board
/RAM/DDR-D6: U9.D8 (DQ6); also elsewhere on the board
/RAM/DDR-D7: U9.E7 (DQ7); also elsewhere on the board
/RAM/DDR-D8: U9.E3 (DQ8); also elsewhere on the board
/RAM/DDR-D9: U9.D2 (DQ9); also elsewhere on the board
/RAM/DDR-D10: U9.D3 (DQ10); also elsewhere on the board
/RAM/DDR-D11: U9.C2 (DQ11); also elsewhere on the board
/RAM/DDR-D12: U9.C3 (DQ12); also elsewhere on the board
/RAM/DDR-D13: U9.B2 (DQ13); also elsewhere on the board
/RAM/DDR-D14: U9.B3 (DQ14); also elsewhere on the board
/RAM/DDR-D15: U9.A2 (DQ15); also elsewhere on the board
/RAM/DDR-LDM: U9.F8 (LDM); also elsewhere on the board
/RAM/DDR-LDQS: U9.E8 (LDQS); also elsewhere on the board
/RAM/DDR-RAS: U9.G9 (RAS#); also elsewhere on the board
/RAM/DDR-UDM: U9.F2 (UDM); also elsewhere on the board
/RAM/DDR-UDQS: U9.E2 (UDQS); also elsewhere on the board
/RAM/DDR-WE: U9.G7 (WE#); also elsewhere on the board
/RAM/RZQ: R29.2; also elsewhere on the board
DDR1V8: C75.1, C76.1, C77.1, C78.1, C79.1, C80.1, C81.1, C82.1, U9.A7 (VDDQ), U9.A9 (VDD), U9.B1 (VDDQ), U9.C9 (VDDQ), U9.D1 (VDDQ), U9.E9 (VDDQ), U9.F9 (VDD), U9.K9 (VDD); also elsewhere on the board
GND: C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, R26.1, R28.2, R29.1, U9.A1 (VSS), U9.A3 (VSSQ), U9.B9 (VSSQ), U9.C1 (VSSQ), U9.D9 (TEST), U9.E1 (VSSQ), U9.F1 (VSS), U9.K1 (VSS); also elsewhere on the board
unnamed: R26.2, U9.H7 (CS#)
