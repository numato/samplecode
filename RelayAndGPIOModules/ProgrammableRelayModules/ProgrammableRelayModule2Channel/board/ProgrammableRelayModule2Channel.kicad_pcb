# Repository numato/samplecode (continued)

## KiCad design Relay And GPIO Modules/Programmable Relay Modules/ProgrammableRelayModule4Channel/board/ProgrammableRelayModule4Channel.kicad_pcb

Board: 2 copper layers, 91.0 x 82.0 mm, 84 parts (8 on the bottom side), 74 nets.

Parts:
1PIN, 1PIN#2: P***; 1pin
1PIN#3, 1PIN#4, 1PIN#5, 1PIN#6: P***; MH-3.2MM
BT1: BATTERY; battery
C1, C3, C4, C5, C7, C9, C11, C12, C15, C16: 0.1uF; SM0805
C2, C17, C18: 10uF; SM1206
C6, C8: 47mfd; SMD_CAP_ELECT_1
C10, C14: 22PF; SM0805
C13: 0.01uF; SM0805
Con6_100mil, Con6_100mil#2, Con6_100mil#3, Con6_100mil#4: VAL**; Con6
D1, D2, D3, D4, D7, D8: LED GREEN; LED-0805
D5: LED; LED-0805
D6: DIODE; SM1206
GS1: GS3; PIN_ARRAY_3X1
GS2: GS2; Sjumber2
IC1: ATMEGA328-NEW; TQFP32
J1: USB; USBMICRO
J2: JACK_2P; JACK_ALIM
K1, K2, K3, K4: CONN_3; ScrewTerm3
NEGATION: VAL**; NEGATION
NEGATION#2, NEGATION#3: VAL**; NEGATION
P2, P4, P5: CONN_4; PIN_ARRAY_4x1
P3: CONN_6; pin_array_3x2
R1, R2, R10, R11, R12: 1K; SM0805
R3: 2k2; RES_NET4
R4, R7, R8: 10k; SM0805
R5, R6, R14, R16: 2K2; SM0805
R9: 4K7; SM0805
R13: NL; SM0603
R15: 1M; SM0805
RL1, RL2, RL3, RL4: RELAY; RelaySugarCube
SW1: SW_PUSH; Switch_SMD
U1: 7805_N; DPAK2
U2: FT232RLNEW; SSOP28
U3: ULN2003; SO16N
U4: FERRITE; SM0805
U5: DS1307; so-8
U6: 74HC4050; so-16
U7: MICRO_SD; MicroSD
U8: MCP1700; SOT23
X2: CRYSTAL; C1V5
X3: 16Mhz CRYSTAL; HC-49V

Connections:
/3V3: C15.2, C18.1, U6.1, U7.4, U8.2
/+5V: C7.1, C8.1, GS1.1, U1.3
/+12V: C4.1, C6.1, C9.1, J2.1, R5.2, R6.2, R14.2, R16.2, RL1.1, RL2.1, RL3.1, RL4.1, U1.1, U3.9
/AREF: C13.1, IC1.20
/DTR: C16.1, U2.2
/FT-RX: IC1.31, R12.1
/FT-TX: IC1.30, R10.1
/PB0: IC1.12, U6.3
/PB1: R3.4, U3.3
/PB1 OUT: D7.2, RL3.2, U3.14
/PB3: IC1.15, P3.4, U6.5
/PB4: IC1.16, P3.3, U7.7
/PB5: IC1.17, P3.2, U6.7
/PC0/ADC0: IC1.23, P5.1
/PC1/ADC1: IC1.24, P5.2
/PC2/ADC2: IC1.25, P5.3
/PC3/ADC3: IC1.26, P5.4
/PD2: R3.8, U3.1
/PD2 OUT: D4.2, RL2.2, U3.16
/PD3: R3.6, U3.2
/PD3 OUT: D3.2, RL1.2, U3.15
/PD4: IC1.2, P4.1
/PD5: IC1.9, P4.2
/PD6: IC1.10, P4.3
/PD7: R3.2, U3.4
/PD7 OUT: D8.2, RL4.2, U3.13
/RESET: C16.2, D6.1, IC1.29, P3.6, R4.1, R13.2, SW1.1
/RTS: R13.1, U2.3
/SCL: IC1.28, P2.2, R8.1, U5.6
/SDA: IC1.27, P2.1, R7.1, U5.5
/VBAT: BT1.1, U5.3
/VBUS: GS1.3, J1.1
/VCC: C1.1, C2.1, C3.1, C11.1, C12.1, C17.1, D6.2, GS2.2, IC1.4, IC1.6, IC1.18, P2.3, P3.1, P4.4, R1.2, R2.2, R4.2, R7.2, R8.2, R9.2, R11.1, U2.4, U2.20, U4.2, U5.8, U8.3
/X1: U5.1, X2.1
/X2: U5.2, X2.2
GND: 1PIN.1, 1PIN#2.1, BT1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C17.2, C18.2, Con6_100mil.1, Con6_100mil#2.1, Con6_100mil#3.1, Con6_100mil#4.1, D5.2, IC1.3, IC1.5, IC1.21, J1.0, J1.4, J1.5, J2.2, J2.3, P2.4, P3.5, SW1.2, U1.2, U2.7, U2.18, U2.21, U2.25, U2.26, U3.8, U5.4, U6.8, U7.6, U7.9, U7.10, U7.11, U7.12, U8.1
unnamed: K3.2, RL3.3
unnamed: K4.3, RL4.5
unnamed: K4.2, RL4.3
unnamed: K4.1, RL4.4
unnamed: K3.3, RL3.5
unnamed: D7.1, R14.1
unnamed: K3.1, RL3.4
unnamed: IC1.1, R3.5
unnamed: D1.1, R1.1
unnamed: D2.1, R2.1
unnamed: IC1.13, R3.3
unnamed: D8.1, R16.1
unnamed: R12.2, U2.5
unnamed: R10.2, U2.1
unnamed: U6.2, U7.2
unnamed: GS2.1, U2.19
unnamed: D3.1, R5.1
unnamed: D5.1, R11.2
unnamed: D2.2, U2.22
unnamed: D1.2, U2.23
unnamed: J1.3, U2.15
unnamed: J1.2, U2.16
unnamed: U6.4, U7.3
unnamed: U6.6, U7.5
unnamed: IC1.11, R3.1
unnamed: GS1.2, U4.1
unnamed: D4.1, R6.1
unnamed: R9.1, U5.7
unnamed: K2.2, RL2.3
unnamed: K2.1, RL2.4
unnamed: K2.3, RL2.5
unnamed: IC1.32, R3.7
unnamed: C5.1, U2.17
unnamed: K1.3, RL1.5
unnamed: K1.2, RL1.3
unnamed: K1.1, RL1.4
unnamed: C14.1, IC1.8, R15.1, X3.1
unnamed: C10.1, IC1.7, R15.2, X3.2

## Commit log

2015-09-24 Moving most of teh code from old repo
2015-11-05 Android sample app initial commit
2015-11-05 First gh-pages commit
2015-11-05 Added USBGenie screenshots
2015-11-06 added screenshots
2015-11-06 added product images
2015-11-06 Resized product images
2015-11-06 Initial version of USBGenie Readme
2015-11-07 Renamed directories to remove spaces
2015-11-13 5 inch TFT LCD code http://numato.com/5inch-tft-lcd-expansion-module.html
2015-11-20 Add USB Device IDs for all current products
2015-11-20 Added support for 8 Channel USB GPIO module (http://numato.com/8-channel-usb-gpio-module-with-analog-inputs/)
2015-11-20 Added support for 16 Channel USB GPIO module (http://numato.com/16-channel-usb-gpio-module-with-analog-inputs/)
2015-11-20 Minor fixes in readme
    Removed brackets from copyright info.
2015-12-28 Added a shebang line to point to Python3 binary
2016-01-16 Added support for 8/16 Channel GPIO USB GPIO Modules
2016-01-20 LCD Expansion Module UCF
2016-01-20 Adding #!/usr/bin/python3
2016-04-03 Switching Blue and Red color
    To get it work on this adapter you need to switch Blue and Red, this is tested on two numato boards, one with adapter, and one without adapter
2016-05-26 Add skoll microblaze sample project
2016-05-26 Correct README.md paths for NumatoVivadoBSB
2016-05-26 Add neso sample microblaze project
2016-06-21 Add neso buildroot config files
2016-06-21 Add skoll linux buildroot config files
2016-06-21 Correct the buildroot config files for skoll
2016-06-22 Changed the 4th argument of CreateFile() call in VBA sample codes from 0 to Null
2016-06-28 Add sample code for AD9763 DAC Expansion Module
2016-06-28 Correct the Readme.txt
2016-08-05 Add Pushbutton Expansion Module sample code for Skoll and Neso
2016-08-05 Add LED Expansion Module sample code for Skoll and Neso
2016-08-05 Add Neso xdc files
2016-08-05 Add VGA Expansion Module sample code for Skoll and Neso
2016-08-05 Add LCDExpansionModule5Inch project for Neso and Skoll
2016-08-05 Add sample code for HDMI transmitter module for Skoll
2016-08-05 Add SevenSegment Expansion Module to Neso and skoll
2016-08-05 Add CS4344 Audio Expansion Module sample code for Skoll
2016-08-05 Add SevenSegment Expansion Module project for Neso and skoll
2016-08-05 Corrected xdc file for Neso
2016-08-05 Add 7 Segment Expansion Module Project sample code for neso and skoll
2016-08-05 Add LCDDisplay 16x2 project samplecode for neso and skoll
2016-08-05 Add LCDDisplay16x2 project samplecode for neso and skoll
2016-08-08 Add sample code for AD9763 DAC expansion module project for Neso and Skoll
2016-08-08 Update text in neso.xdc for AD9763DAC module
2016-08-08 Update text in skoll.xdc for AD9763DAC expansion module
2016-08-08 Update readme.txt with correct ports for neso
2016-08-18 Add ElbertV2 Demonstration Project
2016-08-18 Add MimasV2 Demonstration Project
2016-08-19 Rename Readme.txt to readme.txt
2016-08-19 Rename ipcore_dir to ipcore
2016-08-19 Update ISE project file with correct name for ipcore directory
2016-08-23 Add mimasV2 UART RTL Demonstration project
2016-08-23 Correct project file for MimasV2 UART RTL demo project
2016-08-23 Add bitstreams for MimasV2 UART RTL demo project
2016-08-24 Add ElbertV2 UART RTL demonstration project
2016-08-26 update AD9283ExpansionModule sample code with RTL UART
2016-08-26 correct source files for AD9283ExpansionModule demo code
2016-08-26 Add AD9283ADCExpansionModule demonstration project for skoll
2016-08-29 Add AD9283ADCExpansionModule demonstration project for skoll and MimasV2
2016-08-29 update .xise file for ADCExpansionModule
2016-08-29 Add AC97 Audio Expansion Module Sample Code for Skoll
2016-08-29 Modify Readme.md
2016-08-29 Add AC97AudioExpansionModule demo project for skoll
2016-08-29 Add galatea PCIe communication demo project for galatea
2016-08-29 Modify xpr file for AC97AudioExpansionModule
2016-08-29 Update Vivado project file to version 2016.1 for AC97 Audio Expansion Module
2016-08-30 Add AD9283ADCExpansionModule demonstration project for elbertV2 Fix #17 Fix #18 Fix #19
2016-09-14 Add FX2 USB-UART firmware for Opsis Linux article
2016-09-14 Add Opsis BSB files for EDK
2016-09-14 Add Opsis Linux BSP files
2016-10-21 Add vivado board files for numato boards
2016-10-21 Readme.md for Numato Vivado BSB.
2016-11-29 Add README.md file with instructions on how to install vivado board files
2016-11-29 [styx] Enable feedback clock in preset.xml else uboot fails to identify flash and boot linux
2016-12-22 Update Pushbutton expansion module demo code xdc files
2017-03-03 Add Nereid Vivado board support files
2017-06-13 Updated usage of `serialport` package within the sample (version of serialport package now should be ^4.0.7)
2017-11-17 Update VivadoBSP Readme file
2017-11-28 Adding a faster perl script and a test script to read all 7 ADC channels.
2018-02-26 Updated Nereid BSP image
2018-02-26 Changed nereid image name
2018-03-08 Add Numato Telesto 10M16 configuration file for OpenOCD
2018-03-13 Add tcl file for Telesto ddr3 constraints
2018-03-19 Add galatea buildroot defconfig files
2018-03-21 Updated Styx Vivado BSP image and clock
2018-03-28 Add Neso config file OpenOCD
2018-06-21 Add Numato Telesto 10M50 configuration file for OpenOCD
2018-07-20 nereid: add v3.0 of nereid bsp with PCI Express
2018-08-29 nereid: modified v3.0 of nereid bsp with memory part number
2018-08-31 Fix swapped read/write comments (and some dangeling whitespace my editor trimmed.)
2018-09-03 Added MimasA7 BSP
2018-09-14 Add Mimas A7 buildroot config files
2018-11-21 Add Mimas A7 configuration file for OpenOCD
2019-02-25 Add UART Design for Mimas A7 in Migen
2019-02-25 Add bitstreams of UART design in Migen for Mimas A7
2019-02-26 Add README file for Mimas A7 UART Demo Code in Migen
2019-02-26 Update README file for Mimas A7 UART Demo Code in Migen
2019-02-26 Add Narvi configuration file for OpenOCD
2019-02-26 Added OpenOCD support for Xilinx Spartan 7 50S
2019-02-26 Add README file for Narvi OpenOCD Configuration files
2019-02-26 Add Narvi support in XC3SProg cablelist
2019-02-26 Add Xilinx Spartan 7 25S and 50S support in XC3SProg devlist
2019-02-26 Add README file for Narvi XC3SProg files
2019-02-26 Changed Max_Freq value
2019-02-26 Add Mimas A7 UART output image
2019-02-26 Updated README file
2019-04-09 Add Saturn V3 Linux design files
2019-04-17 Add vivado board files for numato tagus board
2019-05-03 Add vivado board support files for Aller
2019-05-15 Updated BSP to XC7A200T FBG484I -2 support
2019-07-06 [MimasV2] Make sure VGA color lines are at 0V during blanking
2019-07-18 USBGenie: Fix dependency issues
2019-08-28 Add Vivado Board Support files for Proteus
2019-11-12 Added image
2019-11-12 Added Mimas A7 Mini BSP Files
2019-11-13 Added BSP for Narvi Board
2019-11-13 Removed unwanted files
2019-11-14 Create python package for MimasV2Config
2019-11-19 Added vivado board files for numato Narvi board
2019-11-20 Moved Mimas_A7_Mini BSP files into its version folder
2019-11-20 Add Mimas A7 Mini config file OpenOCD
2019-12-03 Added Narvi buildroot config files
2019-12-16 Add Mimas A7 Mini Buildroot Config Files
2020-03-05 Update mig.prj file for the FPGA part number in Aller 200T
2021-01-22 Add vivado Board support files for HSFPX002 FPGA Board
2021-07-05 Rename numato_mimasa7.cfg to numato_mimas_a7.cfg
2021-12-02 Add Callisto K7 Vivado Board Support files
2022-05-04 Create board
2022-05-04 Create aa
2022-05-04 Create 2
2022-12-02 add Saturn_S7
2022-12-15 Add Yoshi's Nightmare game for Icicle Kit
2023-08-24 Basic relay control ash script
